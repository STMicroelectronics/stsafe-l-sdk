# Keil uVision project Project.uvprojx, settings and files
target Debug_STSAFE-L010_project_template (6180000::V6.18::ARMCLANG)
  device: STM32L452RETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Debug_STSAFE-L010_project_template
  AfterMake: fromelf.exe --bin --output=$H@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __VFP_FP__, STM32L452xx, DEBUG
  c include: ..\;..\..\..\Apps_utils;..\..\..\..\;..\..\..\..\Middleware\STM32_Cryptographic\include;..\..\..\..\Middleware\STSELib;..\..\..\..\stse-host-platform;..\..\..\..\stse-host-platform\Core\CMSIS\Include;..\..\..\..\stse-host-platform\Core\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\stse-host-platform\STSELib;..\..\..\..\stse-crypto-platform;..\..\..\..\stse-crypto-platform\STSELib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group App
    ../: main.c stse_conf.h
    ../../../Apps_utils/: Apps_utils.c
  group Middleware/STM32CryptoLib
    ../../../../Middleware/STM32_Cryptographic/interface/: cmox_low_level_template.c
    ../../../../Middleware/STM32_Cryptographic/lib/: libSTM32Cryptographic_CM4.a
  group Middleware/STSELib/api
    ../../../../Middleware/STSELib/api/: stse_aes.c stse_asymmetric_keys_management.c stse_data_storage.c stse_derive_keys.c stse_device_authentication.c stse_device_management.c stse_ecc.c stse_hash.c stse_mac.c stse_random.c stse_symmetric_keys_management.c
  group Middleware/STSELib/Cerficate
    ../../../../Middleware/STSELib/certificate/: stse_certificate.c stse_certificate_crypto.c stse_certificate_prints.c stse_certificate_subparsing.c
  group Middleware/STSELib/Core
    ../../../../Middleware/STSELib/core/: stse_device.c stse_frame.c stse_generic_typedef.c stse_platform.c stse_session.c
  group Middleware/STSELib/Services/STSAFE-A
    ../../../../Middleware/STSELib/services/stsafea/: stsafea_aes.c stsafea_asymmetric_key_slots.c stsafea_commands.c stsafea_data_partition.c stsafea_derive_keys.c stsafea_ecc.c stsafea_echo.c stsafea_entity_auth.c stsafea_frame_transfer.c stsafea_hash.c stsafea_host_key_slot.c stsafea_low_power.c stsafea_mac.c stsafea_password.c stsafea_patch.c stsafea_public_key_slots.c stsafea_put_query.c stsafea_random.c stsafea_reset.c stsafea_sessions.c stsafea_symmetric_key_slots.c stsafea_timings.c stsafea_wrap_unwrap.c
  group Middleware/STSELib/Services/STSAFE-L
    ../../../../Middleware/STSELib/services/stsafel/: stsafel_commands.c stsafel_data_partition.c stsafel_device_info.c stsafel_ecc.c stsafel_echo.c stsafel_frame_transfer.c stsafel_low_power.c stsafel_reset.c stsafel_timings.c
  group stse-host-platform/Core
    ../../../../stse-host-platform/Core/CMSIS/Device/ST/STM32L4xx/Source/: system_stm32l4xx.c
    ../../../../stse-host-platform/Core/CMSIS/Device/ST/STM32L4xx/Source/arm/: startup_stm32l452xx.s
  group stse-host-platform/Drivers
    ../../../../stse-host-platform/Drivers/crc16/: crc16.c
    ../../../../stse-host-platform/Drivers/delay_ms/: delay_ms.c
    ../../../../stse-host-platform/Drivers/delay_us/: delay_us.c
    ../../../../stse-host-platform/Drivers/i2c/: I2C.c
    ../../../../stse-host-platform/Drivers/rng/: rng.c
    ../../../../stse-host-platform/Drivers/uart/: uart.c
    ../../../../stse-host-platform/Drivers/st1wire/: st1wire.c st1wire_platform.c
  group stse-host-platform/STSELib
    ../../../../stse-host-platform/STSELib/: stse_platform_crc.c stse_platform_delay.c stse_platform_power.c stse_platform_random.c stse_platform_i2c.c stse_platform_st1wire.c
  group stse-crypto-platform/STSELib
    ../../../../stse-crypto-platform/STSELib/: stse_platform_aes.c stse_platform_crypto_init.c stse_platform_ecc.c stse_platform_hash.c
target Release_STSAFE-L010_project_template (6180000::V6.18::ARMCLANG)
  device: STM32L452RETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: as above
  output: Release_STSAFE-L010_project_template
  AfterMake: fromelf.exe --bin --output=$H@L.bin !L
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __VFP_FP__, STM32L452xx
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x8000
software components: CMSIS:CORE 5.6.0
